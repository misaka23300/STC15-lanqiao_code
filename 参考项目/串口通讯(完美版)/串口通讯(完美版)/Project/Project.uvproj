# Keil uVision project Project.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Project;..\User;..\User\Inc
  link misc: REMOVEUNUSED
  group Src
    ../User/Src/: main.c Timer.c SMG.c UART.c LED.c Sys.c
  group Inc
    ../User/Inc/: Timer.h SMG.h UART.h LED.h Sys.h config.h
  group Doc
    ../Doc/: Readme.txt
