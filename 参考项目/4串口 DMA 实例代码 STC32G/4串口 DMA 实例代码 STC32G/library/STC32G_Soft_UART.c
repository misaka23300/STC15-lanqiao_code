/*---------------------------------------------------------------------*/
/* --- STC MCU Limited ------------------------------------------------*/
/* --- STC 1T Series MCU Demo Programme -------------------------------*/
/* --- Mobile: (86)13922805190 ----------------------------------------*/
/* --- Fax: 86-0513-55012956,55012947,55012969 ------------------------*/
/* --- Tel: 86-0513-55012928,55012929,55012966 ------------------------*/
/* --- Web: www.STCAI.com ---------------------------------------------*/
/* --- Web: www.STCMCUDATA.com  ---------------------------------------*/
/* --- BBS: www.STCAIMCU.com  -----------------------------------------*/
/* --- QQ:  800003751 -------------------------------------------------*/
/* Èç¹ûÒªÔÚ³ÌÐòÖÐÊ¹ÓÃ´Ë´úÂë,ÇëÔÚ³ÌÐòÖÐ×¢Ã÷Ê¹ÓÃÁËSTCµÄ×ÊÁÏ¼°³ÌÐò            */
/*---------------------------------------------------------------------*/

/*************	¹¦ÄÜËµÃ÷	**************

±¾ÎÄ¼þÎªÄ£Äâ´®¿Ú·¢ËÍ³ÌÐò, Ò»°ãÎª²âÊÔ¼à¿ØÓÃ.

´®¿Ú²ÎÊý:9600,8,n,1.

¿ÉÒÔ¸ù¾ÝÖ÷Ê±ÖÓ×Ô¶¯ÊÊÓ¦.

******************************************/

#include "STC32G_Soft_UART.h"

sbit	P_TXD = P1^7;	//¶¨ÒåÄ£Äâ´®¿Ú·¢ËÍ¶Ë,¿ÉÒÔÊÇÈÎÒâIO

//========================================================================
// º¯Êý: void BitTime(void)
// ÃèÊö: Î»Ê±¼äº¯Êý¡£
// ²ÎÊý: none.
// ·µ»Ø: none.
// °æ±¾: VER1.0
// ÈÕÆÚ: 2013-4-1
// ±¸×¢: 
//========================================================================
void BitTime(void)
{
	u16 i;
	i = ((MAIN_Fosc / 100) * 138) / 80000L - 1;		//¸ù¾ÝÖ÷Ê±ÖÓÀ´¼ÆËãÎ»Ê±¼ä
	while(--i);
}

//========================================================================
// º¯Êý: void TxSend(uchar dat)
// ÃèÊö: Ä£Äâ´®¿Ú·¢ËÍÒ»¸ö×Ö½Ú¡£9600£¬N£¬8£¬1
// ²ÎÊý: dat: Òª·¢ËÍµÄÊý¾Ý×Ö½Ú.
// ·µ»Ø: none.
// °æ±¾: VER1.0
// ÈÕÆÚ: 2013-4-1
// ±¸×¢: 
//========================================================================
void TxSend(u8 dat)
{
	u8	i;
	EA = 0;
	P_TXD = 0;
	BitTime();
	for(i=0; i<8; i++)
	{
		if(dat & 1)		P_TXD = 1;
		else			P_TXD = 0;
		dat >>= 1;
		BitTime();
	}
	P_TXD = 1;
	EA = 1;
	BitTime();
	BitTime();
}

//========================================================================
// º¯Êý: void PrintString(unsigned char code *puts)
// ÃèÊö: Ä£Äâ´®¿Ú·¢ËÍÒ»´®×Ö·û´®¡£9600£¬N£¬8£¬1
// ²ÎÊý: *puts: Òª·¢ËÍµÄ×Ö·ûÖ¸Õë.
// ·µ»Ø: none.
// °æ±¾: VER1.0
// ÈÕÆÚ: 2013-4-1
// ±¸×¢: 
//========================================================================
void PrintString(unsigned char code *puts)
{
    for (; *puts != 0;	puts++)  TxSend(*puts);
}

