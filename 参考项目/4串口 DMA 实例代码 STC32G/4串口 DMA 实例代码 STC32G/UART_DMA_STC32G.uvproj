# Keil uVision project UART_DMA_STC32G.uvproj, settings and files
target STC32G_UART_Demo (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: UART_DMA_STC32G +hex
  link misc: REMOVEUNUSED
  group UART
    ./: UART1.C UART2.C UART3.C UART4.C
  group USER
    ./: main.c 代码说明.txt
