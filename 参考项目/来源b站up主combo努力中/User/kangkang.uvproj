# Keil uVision project kangkang.uvproj, settings and files
target kangkang (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: kangkang +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Init.c Init.h Led.c Led.h Key.c Key.h Seg.c Seg.h ds1302.c ds1302.h
