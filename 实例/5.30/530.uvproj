# Keil uVision project 530.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 530 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user\inc;.\driver\inc
  group main
    ./: STARTUP.A51
    ./user/main/: boot.c main.c uart.c
  group driver
    ./driver/main/: key.c led.c onewire.c seg.c
