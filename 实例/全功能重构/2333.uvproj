# Keil uVision project 2333.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2333 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include\
  group c
    ./main/: boot.c key.c led.c main.c seg.c
    ./include/: boot.h key.h led.h main.h seg.h task.h
