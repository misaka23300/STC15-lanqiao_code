# Keil uVision project aicubes_bk1.uvproj, settings and files
target aicubes (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000)
  output: aicubes +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\inc
  group AiCube
    ./Sources/: main.c port.c clock.c timer.c uart.c pca.c
