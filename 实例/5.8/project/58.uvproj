# Keil uVision project 58.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 58 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code\driver\include;..\code\user\include
  group user
    ./: STARTUP.A51
    ../code/user/main/: boot.c main.c task.c
  group driver
    ../code/driver/main/: key.c seg.c
