# Keil uVision project 14.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 14 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code\include
  group main
    ./: STARTUP.A51
    ../code/user/: boot.c main.c module.c log.c
  group driver
    ../code/driver/: ds1302.c iic.c onewire.c key.c led.c seg.c
