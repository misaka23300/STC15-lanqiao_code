# Keil uVision project 1555.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 1555 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./code/: display.c key.c machine.c main.c display.h key.h machine.h main.h uart.c uart.h sonic.c sonic.h iic.c iic.h
