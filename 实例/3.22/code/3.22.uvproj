# Keil uVision project 3.22.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 3.22 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./code/: boot.c key.c led.c main.c seg.c boot.h key.h led.h main.h seg.h ds1302.c iic.c iic.h ds1302.h
