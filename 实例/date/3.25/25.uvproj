# Keil uVision project 25.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 25 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 boot.c key.c led.c main.c seg.c seg.h main.h led.h key.h boot.h sonic.c
