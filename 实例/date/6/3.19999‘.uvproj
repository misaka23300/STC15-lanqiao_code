# Keil uVision project 3.19999‘.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 3.19999‘ +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 boot.c key.c led.c ne555.c seg.c sonic.c boot.h key.h led.h ne555.h seg.h sonic.h main.c main.h onewire.c onewire.h
