# Keil uVision project 流水灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 流水灯
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    $TC_ROOT$/../../code_V5.0/clone/STC15-lanqiao_code/模块/1.2 led/流水灯/: led.c led.h
