# Keil uVision project uaRt.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: uaRt +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code\include
  group main
    ../code/main/: boot.c main.c uart.c
  group include
    ../code/include/: boot.h main.h uart.h
