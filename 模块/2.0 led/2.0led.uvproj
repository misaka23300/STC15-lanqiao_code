# Keil uVision project 2.0led.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2.0led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group main
    ./: STARTUP.A51
    ./main/: main.c
  group include
    ./include/: main.h
