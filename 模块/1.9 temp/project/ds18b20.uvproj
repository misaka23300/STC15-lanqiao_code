# Keil uVision project ds18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ds18b20 +hex
  group Source Group 1
    ./: STARTUP.A51
